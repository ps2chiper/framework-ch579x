# Keil uVision project BLE.uvproj, settings and files
target BLE_ImageA (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ImageA +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: DEBUG
  c include: ..\APP\include;..\Profile\include;..\..\HAL\include;..\..\LIB;..\..\..\SRC\CMSIS\Include;..\..\..\SRC\StdPeriphDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1f400
  memory RVCT9: RAM 0x20004000 size 0x4000
  group app
    ../APP/: Peripheral.c Peripheral_main.c
  group profile
    ../Profile/: devinfoservice.c GATTprofile.c OTAprofile.c
  group drive
    ../../../SRC/Startup/: startup_ARMCM0.s
    ../../../SRC/StdPeriphDriver/: CH57x_clk.c CH57x_gpio.c CH57x_pwr.c CH57x_sys.c CH57x_uart1.c CH57x_flash.c
  group hal
    ../../HAL/: MCU.c RTC.c SLEEP.c
  group lib
    ../../LIB/: CH57xBLE.LIB
  group config
    ../APP/include/: config.h
target BLE_ImageB (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ImageB +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: DEBUG
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1f400 size 0x1f400
  memory RVCT9: RAM 0x20004000 size 0x4000
