# Keil uVision project CH57x.uvproj, settings and files
target CH57x (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: CH57x +hex
  c flags: Optim=1
  c define: DEBUG
  c include: ..\..\SRC\CMSIS;..\..\SRC\Startup;..\..\SRC\StdPeriphDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x3e800
  memory RVCT9: RAM 0x20000000 size 0x4000
  memory RVCT10: RAM 0x20004000 size 0x4000
  group user
    ./: Main.c SPIFlash.C
  group peripheral
    ../../SRC/StdPeriphDriver/: CH57x_adc.c CH57x_clk.c CH57x_flash.c CH57x_gpio.c CH57x_lcd.c CH57x_pwm.c CH57x_pwr.c CH57x_spi0.c CH57x_spi1.c CH57x_sys.c CH57x_timer0.c CH57x_uart1.c CH57x_usbdev.c CH57x_usbhostBase.c CH57x_usbhostClass.c
  group startup
    ../../SRC/Startup/: startup_ARMCM0.s
